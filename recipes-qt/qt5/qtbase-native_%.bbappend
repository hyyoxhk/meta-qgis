PACKAGECONFIG += "gui imageformats openssl"
