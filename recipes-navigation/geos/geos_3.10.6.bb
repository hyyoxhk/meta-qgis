require geos.inc

SRC_URI[md5sum] = "517e7dae51c45ca6878a3e20ea5f9549"
SRC_URI[sha256sum] = "078403158da66cad8be39ad1ede5e2fe4b70dcf7bb292fb06a65bdfe8afa6daf"